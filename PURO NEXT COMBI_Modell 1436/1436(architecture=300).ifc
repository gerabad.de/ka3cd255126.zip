Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_47/temp/tmp_2780_82_aRb7b/format_3/1436(architecture=300).ifc
Time: 2025-08-11T06:11:42
Made in: PARTsolutions

# IfcProject, 1436(architecture=300)
Description: PURO NEXT COMBI

# IfcDiscreteAccessory, 1436(architecture=300)
In: BUILDING
Description: 1436(architecture=300)
Pset_ManufacturerTypeInformation - Manufacturer: KALDEWEI; ArticleNumber: 1436
ePset_PARTsolutions - NB: 1436(architecture=300); NN: 1436; NT: PURO NEXT COMBI; NBSYN: $A.($LODDEST.=$LODLEVEL.); LINA: 1436(architecture=300); CATALOG: Kaldewei; LODLEVEL: 300; A: 1436; B: 1436.png; C: PURO NEXT COMBI; E: KALDEWEI; EF000049: 1800; EF004567: 800
